Commit message: initial commit

File: assets/urdf/cartpole.urdf (robot description, URDF)
Before this commit: robot cartpole, 3 links, 2 joints
Links:
- link pole: geometry collision box size=0.04 0.06 2.0; visual box size=0.04 0.06 2.0
